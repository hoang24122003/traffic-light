# Keil uVision project Traffic.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Traffic +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers
    ./: stm32f103xx_gpio_driver.c stm32f103xx_gpio_driver.h stm32f103xx.h
  group Users Code
    ./: main.c
  group LCD1602
    ./: LCDFunctions.c LCDFunctions.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
